# Repository Zulljon/rover_commander

File README.md:

# Rover Commander v3.1a
PCB part of project (source codes unavailable!)

## Scheme

## PCB

## Tools
- KiCAD v4.0.7

## KiCad design rover_commander.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C3, C5, C8, C11, C14, C16, C17, C18, C19: 100nf; C_0603_HandSoldering
C2: 220uF x 30V; CP_Radial_D5.0mm_P2.50mm
C4: 0.33uF; C_0603_HandSoldering
C6: 0.1uF; C_0603_HandSoldering
C7: 100nF; C_0603_HandSoldering
C9, C13, C20, C21: 12pf; C_0603_HandSoldering
C10: 10uF; C_0603_HandSoldering
C12: 4.7uF x 10V; CP_Radial_D5.0mm_P2.50mm
C15: 22uF x 10V; CP_Radial_D5.0mm_P2.50mm
C22: 10pF; C_0603_HandSoldering
D1: PMLL4148L.115; D_SC-80_HandSoldering
D2, D4, D5, D9, D10: 1N5819HW-7-F; D_SOD-123
D3: BAT54A; SOT-23
D6: M4 BAV16W or 1N4148WS; D_SOD-323_HandSoldering
D7, D8: SMAJ33CA-TR; D_SMA
D11: LED BLUE; LED_0603_HandSoldering
J1: GS2
L1, L2: 4R7K; L_1210_HandSoldering
LED1: LED_Dual_CAC; LED_D5.0mm-3
LED2: LED_Dual_ACA 5mm R G; LED_D5.0mm-3
Q1, Q2: Crystal KX-7 25MHz; Crystal_SMD_7050-4pin_7.0x5.0mm
R1, R3, R4, R5: 49.9 Ohm 1%; R_0603_HandSoldering
R2, R10, R11, R12, R13, R14: 4k7; R_0603_HandSoldering
R6: 2k 1%; R_0603_HandSoldering
R7, R15: 200; R_0603_HandSoldering
R8, R9: 75; R_0603_HandSoldering
R16, R19: 22; R_0603_HandSoldering
R17, R18: 680; R_0603_HandSoldering
R20: 10k; R_0603_HandSoldering
R21: 9k; R_0603_HandSoldering
R22, R23: 2k2; R_0603_HandSoldering
R24, R25: 60; R_0603_HandSoldering
R26, R27, R30: 100k; R_0603_HandSoldering
R28: 240; R_0603_HandSoldering
R29: 120; R_0603_HandSoldering
R31: 1k; R_0603_HandSoldering
U1: RTL8201CP; LQFP-48_7x7mm_Pitch0.5mm
U2: L7805ABD2T-TR; TO254P1542X460-3N; Manufacturer_Part_Number L7805ABD2T-TR
U3: H1102NLT; SOIC-16W_7.5x12.8mm_Pitch1.27mm
U4: AMS1117-ADJ; SOT-223-3Lead_TabPin2
U5: STM32F107RCTx; LQFP-64_10x10mm_Pitch0.5mm_datesheet
U6: TJA1040T; SOIC-8_3.9x4.9mm_Pitch1.27mm
U7: M95160-WMN6TP; SOIC-8_3.9x4.9mm_Pitch1.27mm; Manufacturer_Part_Number M95160-WMN6TP
VT1: Y2 or SS8550; SOT-23
XP1: USB_B
XP2: NOT_FITTED_SWD_Conn_01x04; Pin_Header_Straight_1x04_Pitch2.54mm
XP3: NOT_FITTED_Conn_01x10_OBD2; Pin_Header_Straight_1x10_Pitch2.54mm

Connections:
/+3V3_EEPROM: D10.1 (K), R26.1, U7.8 (VCC)
/+3V3_ETH: C11.1, C14.1, C16.1, C17.1, D9.1 (K), L1.2, LED1.2 (A), R2.2, R10.1, R11.1, R12.1, R13.1, R14.1, U1.14 (DVDD33), U1.37 (ANE), U1.38 (DUPLEX), U1.39 (SPEED), U1.41 (LDPS), U1.43 (ISOLATE), U1.48 (DVDD33)
/+3V3_STM: D5.1 (K), R30.1, U5.1 (VBAT), U5.13 (VDDA), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), XP2.4
/+3V65: C10.1, C12.1, D5.2 (A), D9.2 (A), D10.2 (A), R29.1, R31.1, U4.2 (VO)
/+5V: C7.1, D2.1 (K), D4.1 (K), U4.3 (VI), U6.3 (VCC), VT1.2 (E)
/ADC_Vbat: R21.2, R22.1, U5.21 (ADC1_IN5/ADC2_IN5/DAC_OUT2/SPI1_SCK/PA5)
/BUZZER: R23.2, U5.22 (ADC1_IN6/ADC2_IN6/SPI1_MISO/TIM1_BKIN/T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)
/CAN_RX: U5.57 (CAN2_RX/ETH_PPS_OUT/I2C1_SMBA/I2S3_SD/S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), U6.4 (RXD)
/CAN_TX: U5.58 (CAN2_TX/I2C1_SCL/TIM4_CH1/USART1_TX/PB6), U6.1 (TXD)
/EEPROM_CS: R26.2, U5.20 (ADC1_IN4/ADC2_IN4/DAC_OUT1/I2S3_WS/SPI1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), U7.1 (~S)
/EEPROM_MISO: U5.52 (PC11/ADC1_EXTI11/ADC2_EXTI11/SPI3_MISO/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), U7.2 (Q)
/EEPROM_MOSI: U5.53 (PC12/I2S3_SD/SPI3_MOSI/UART5_TX/USART3_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), U7.5 (D)
/EEPROM_SCK: R27.2, U5.51 (PC10/I2S3_CK/SPI3_SCK/UART4_TX/USART3_TX), U7.6 (C)
/ETH_MDC: U1.25 (MDC), U5.9 (PC1/ADC1_IN11/ADC2_IN11/ETH_MDC)
/ETH_MII_COL: U1.1 (COL), U5.17 (ADC1_IN3/ADC2_IN3/ETH_COL/TIM2_CH4/TIM5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)
/ETH_MII_CRS: U1.23 (CRS), U5.14 (ADC1_IN0/ADC2_IN0/ETH_CRS/SYS_WKUP/TIM2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)
/ETH_MII_RXD1: U1.20 (RXD1), U5.25 (PC5/ADC1_IN15/ADC2_IN15/ETH_RXD1)
/ETH_MII_RXD2: U1.19 (RXD2), U5.26 (ADC1_IN8/ADC2_IN8/ETH_RXD2/TIM1_CH2N/TI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)
/ETH_MII_RXD3: U1.18 (RXD3), U5.27 (ADC1_IN9/ADC2_IN9/ETH_RXD3/TIM1_CH3N/TI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)
/ETH_MII_RXDO: U1.21 (RXD0), U5.24 (PC4/ADC1_IN14/ADC2_IN14/ETH_RXD0)
/ETH_MII_RX_CLK: U1.16 (RXC), U5.15 (ADC1_IN1/ADC2_IN1/ETH_REF_CLK/ETH_RX_CL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)
/ETH_MII_RX_DV: U1.22 (RXDOV), U5.23 (ADC1_IN7/ADC2_IN7/ETH_CRS_DV/ETH_RX_DV/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)
/ETH_MII_RX_ER: U1.24 (RXER), U5.29 (ETH_RX_ER/TIM2_CH3/USART3_TX/PB10)
/ETH_MII_TXD0: U1.6 (TXD0), U5.33 (CAN2_RX/ETH_TXD0/I2S2_WS/SPI2_NSS/TIM1_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)
/ETH_MII_TXD1: U1.5 (TXD1), U5.34 (CAN2_TX/ETH_TXD1/I2S2_CK/SPI2_SCK/TIM1_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)
/ETH_MII_TXD2: U1.4 (TXD2), U5.10 (PC2/ADC1_IN12/ADC2_IN12/ETH_TXD2)
/ETH_MII_TXD3: U1.3 (TXD3), U5.61 (CAN1_RX/ETH_TXD3/I2C1_SCL/TIM4_CH3/PB8)
/ETH_MII_TX_CLK: U1.7 (TXC), U5.11 (PC3/ADC1_IN13/ADC2_IN13/ETH_TX_CLK)
/ETH_MII_TX_EN: U1.2 (TXEN), U5.30 (ADC1_EXTI11/ADC2_EXTI11/ETH_TX_EN/TIM2_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)
/ETH_MIO: R2.1, U1.26 (MDIO), U5.16 (ADC1_IN2/ADC2_IN2/ETH_MDIO/TIM2_CH3/TIM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)
/ETH_RST: U1.42 (RESETB), U5.39 (PC8/TIM3_CH3)
/OBD2_CAN_H: D7.2 (A2), R24.2, U6.7 (CANH), XP3.7
/OBD2_CAN_L: D8.2 (A2), R25.2, U6.6 (CANL), XP3.8
/OBD2_RX+: U3.11 (RX+), XP3.3
/OBD2_RX-: U3.9 (RX-), XP3.4
/OBD2_TX+: U3.16 (TX+), XP3.1
/OBD2_TX-: U3.14 (TX-), XP3.2
/OBD2_Vbat: D1.2 (A), XP3.10
/STM_ADC_12V: C2.1, C4.1, D1.1 (K), R21.1, U2.1 (INPUT)
/TRANSF_RX+: R4.1, U1.31 (TPRX+), U3.6 (RD+)
/TRANSF_RX-: R5.1, U1.30 (TPRX-), U3.8 (RD-)
/TRANSF_TX+: R1.1, U1.34 (TPTX+), U3.1 (TD+)
/TRANSF_TX-: R3.1, U1.33 (TPTX-), U3.3 (TD-)
/TRANS_CT: C1.1, C15.1, C18.1, L2.1, U1.32 (PWFBOUT), U3.2 (CT), U3.7 (CT)
/USB_+: R16.1, XP1.3 (D+)
/USB_-: R19.1, XP1.2 (D-)
/USB_D+: R16.2, U5.45 (CAN1_TX/TIM1_ETR/USART1_RTS/USB_OTG_FS_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)
/USB_D-: R19.2, U5.44 (ADC1_EXTI11/ADC2_EXTI11/CAN1_RX/TIM1_CH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)
/USB_Vbus: D4.2 (A), U5.42 (DAC_EXTI9/TIM1_CH2/USART1_TX/USB_OTG_FS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), XP1.1 (VBUS)
GND: BZ1.2 (+), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D6.2 (A), D7.1 (A1), D8.1 (A1), D11.1, LED2.2 (K), Q1.2, Q1.4, Q2.2, Q2.4, R6.1, R8.2, R9.1, R20.2, R22.2, R27.1, R28.2, U1.11 (DGND), U1.17 (DGND), U1.29 (AGND), U1.35 (AGND), U1.40 (RPTR/RTT2), U1.44 (MII/SNIB), U1.45 (DGND), U2.4 (GND_(TAB)), U5.12 (VSSA), U5.18 (VSS), U5.31 (VSS), U5.47 (VSS), U5.63 (VSS), U6.2 (GND), U7.4 (VSS), XP1.4 (GND), XP1.5 (Shield), XP2.1, XP3.5, XP3.6
unnamed: BZ1.1 (-), D6.1 (K), VT1.3 (C)
unnamed: C3.1, R1.2, R3.2
unnamed: C5.1, R4.2, R5.2
unnamed: C6.1, D2.2 (A), U2.3 (OUTPUT)
unnamed: C8.1, L1.1, U1.36 (AVDD33)
unnamed: C9.1, Q1.1, U1.46 (X1)
unnamed: C13.1, Q1.3, U1.47 (X2)
unnamed: C19.1, L2.2, U1.8 (DVDD0/PWFBIN)
unnamed: C20.1, Q2.1, U5.5 (PD0/RCC_OSC_IN)
unnamed: C21.1, Q2.3, U5.6 (PD1/RCC_OSC_OUT)
unnamed: C22.1, R24.1, R25.1, U6.5 (SPLIT)
unnamed: D3.1 (K), R13.2, U1.13 (PHYAD3/LED3)
unnamed: D3.2 (K), R12.2, U1.12 (PHYAD2/LED2)
unnamed: D3.3 (A), R15.2
unnamed: D11.2, R31.2
unnamed: J1.1 (G1), U5.7 (NRST)
unnamed: J1.2 (G2), R30.2
unnamed: LED1.1 (K1), R15.1
unnamed: LED1.3 (K2), R7.1
unnamed: LED2.1 (A1), R18.2
unnamed: LED2.3 (A2), R17.2
unnamed: R6.2, U1.28 (RTSET)
unnamed: R8.1, U3.15
unnamed: R9.2, U3.10
unnamed: R7.2, R10.2, U1.9 (PHYAD0/LED0)
unnamed: R11.2, U1.10 (PHYAD1/LED1)
unnamed: R14.2, U1.15 (PHYAD4/LED4)
unnamed: R17.1, U5.3 (PC14/RCC_OSC32_IN)
unnamed: R18.1, U5.2 (PC13/RTC_OUT/RTC_TAMPER)
unnamed: R20.1, U6.8 (STB)
unnamed: R23.1, VT1.1 (B)
unnamed: R28.1, R29.2, U4.1 (ADJ)
unnamed: U5.46 (SYS_JTMS-SWDIO/PA13), XP2.3
unnamed: U5.49 (SYS_JTCK-SWCLK/PA14), XP2.2

Notes on the sheet:
R29 connection must be realized very close to OUT and ADJ pin, while R28 ground connection must be placed as near as possible to the negative Load pin.
U4 setup to 3.65V output Uf on shottky doids 0.35V (1n5819)
Not Fited

Board: 2 copper layers, 77.0 x 42.0 mm, 83 parts (49 on the bottom side), 84 nets.

## Commit log

2017-10-19 asd1
2017-10-20 finish tracing
2017-10-20 add OBD@ connecters labels on front silk layer
2017-10-20 fix missing arm, fill layer with GND
2017-10-20 renew image
2017-10-20 add bill of material
2017-10-22 generate GERBERS files
2017-10-22 add .gitignore README
2017-10-22 add image to readme
2017-10-25 fix silk layer and some DRC errors
2017-10-25 update gerbers (nornal and protel format)
2017-10-25 fix silk layer
2017-11-09 fix swd connector, reversed GND and POWER +3.3V
2017-11-09 add scheme image to github readme
2017-11-15 switch to my library https://github.com/Zulljon/zpkl.git
2017-11-24 add transient voltage suppression diods on CAN
2017-11-27 fix crystals package, add thermo-pads to voltage regulator, fix usb like differential pair
2017-12-02 fix files mods(permission)
2017-12-07 add shell script to zip gerbers
2017-12-07 generate gerber files
2017-12-07 zipped gerber files
2017-12-08 add descriptions for gerber files
2017-12-08 add BOM file
2018-01-24 update pcb file
2018-01-24 update schematic
2018-02-05 fix to relative libs path
2018-02-13 fix ICs libs, add .sh jobs, plot .sch to .png & .pdf
2018-02-13 .gitignore is now working
2018-02-13 rename all files
2018-02-15 fix job.sh after mass rename
2018-02-15 power fix, diods replace with shottky, eeprom package, extra pull-up on reset
2018-02-15 change perm a+rwx to a+rw
2018-05-15 fix eeprom NSS pin to correct one
2018-05-15 shell script now check if we need update zip and delete gerbers
2018-05-15 fix stm32 footprint as advised in datasheet, fix libs paths
2018-06-02 add blue LED on power supplier of stm32
